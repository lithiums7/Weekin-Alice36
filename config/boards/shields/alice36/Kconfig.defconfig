## config/boards/shields/alice36/Kconfig.defconfig
```kconfig
if SHIELD_ALICE36

config ZMK_KEYBOARD_NAME
    default "Weekin Alice 36"

endif
```
